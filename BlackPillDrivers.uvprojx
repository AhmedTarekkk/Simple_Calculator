# Keil uVision project BlackPillDrivers.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BlackPillDrivers
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: F_CPU=16000000
  c misc: -Wno-declaration-after-statement -Wno-gnu-binary-literal -Wno-missing-prototypes -Wno-missing-variable-declarations -Wno-conditional-uninitialized
  c include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./src/: main.c
  group MCAL
    ./src/: RCC.c GPIO.c STK.c
  group HAL
    ./src/: LCD.c KEYPAD.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
